** sch_path: xschem/untitled.sch
**.subckt untitled xxx xxx xxx
*.opin xxx
*.ipin xxx
*.iopin xxx
R1 xxx xxx 1k m=1
C1 xxx xxx 1p m=1
**.ends
.end
