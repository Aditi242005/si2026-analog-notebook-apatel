v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {rc_ckt.sym} -20 -20 0 0 {name=x1}
C {vsource.sym} -200 30 0 0 {name=V1 value=3 savecurrent=false}
